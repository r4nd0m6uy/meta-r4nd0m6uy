require gitolite.inc

SRCREV = "908f8c6f3b8ef5b95829be7155be2557e71f4579"
